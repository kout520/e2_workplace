# Keil uVision project FS-STM32U575-Total.uvprojx, settings and files
target FS-STM32U575-Total (6180000::V6.18::ARMCLANG)
  device: STM32U575RITx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x30000000,0x00030000) IROM(0x08000000,0x00200000) IROM2(0x0C000000,0x00200000) XRAM(0x20030000,0x00010000) XRAM2(0x30030000,0x00010000) XRAM3(0x20040000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: FS-STM32U575-Total +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U575xx,LINK_HARDWARE
  c include: ../Core/Inc;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../Drivers/STM32U5xx_HAL_Driver/Inc;../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../Drivers/CMSIS/Include;../Drivers/Motion_Driver;../Drivers/efsm-master/efsm;../Drivers/MAX30102_Maxim;../code;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT6: RAM 0x20030000 size 0x10000
  memory RVCT7: RAM 0x30030000 size 0x10000
  memory RVCT8: RAM 0x20040000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x30000000 size 0x30000
  scatter file: FS-STM32U575-Total\FS-STM32U575-Total.sct
  group Application/MDK-ARM
    ./: startup_stm32u575xx.s
  group Application/User/Core
    ../Core/Src/: bsp_ft6336.c bsp_ili9341_4line.c bsp_ospi_w25q128.c user_app.c bsp_sht20.c bsp_ap3216c.c bsp_esp8266.c main.c gpio.c adc.c crc.c gpdma.c i2c.c icache.c memorymap.c octospi.c rtc.c spi.c tim.c usart.c stm32u5xx_it.c stm32u5xx_hal_msp.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXDMA.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_adc.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_crc.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_ospi.c stm32u5xx_ll_dlyb.c stm32u5xx_hal_rtc.c stm32u5xx_hal_rtc_ex.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group gui
    ../touchgfx/gui/src/adc_screen/: adcpresenter.cpp adcview.cpp
    ../touchgfx/gui/src/are_screen/: arepresenter.cpp areview.cpp
    ../touchgfx/gui/src/coutton_screen/: couttonpresenter.cpp couttonview.cpp
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/heat_screen/: heatpresenter.cpp heatview.cpp
    ../touchgfx/gui/src/homescreen_screen/: homescreenpresenter.cpp homescreenview.cpp
    ../touchgfx/gui/src/main_page_screen/: main_pagepresenter.cpp main_pageview.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/oula_screen/: oulapresenter.cpp oulaview.cpp
    ../touchgfx/gui/src/timer_screen/: timerpresenter.cpp timerview.cpp
    ../touchgfx/gui/src/vcc_screen/: vccpresenter.cpp vccview.cpp
    ../touchgfx/gui/src/wifi_screen/: wifipresenter.cpp wifiview.cpp
  group generated
    ../touchgfx/generated/gui_generated/src/adc_screen/: adcviewbase.cpp
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_cambriaz_40_4bpp_0.cpp font_simkai_16_4bpp_0.cpp font_simkai_16_4bpp_10.cpp font_simkai_16_4bpp_11.cpp font_simkai_16_4bpp_12.cpp font_simkai_16_4bpp_13.cpp font_simkai_16_4bpp_14.cpp font_simkai_16_4bpp_15.cpp font_simkai_16_4bpp_16.cpp font_simkai_16_4bpp_17.cpp font_simkai_16_4bpp_18.cpp font_simkai_16_4bpp_19.cpp font_simkai_16_4bpp_9.cpp font_simkai_20_4bpp_0.cpp font_simkai_20_4bpp_10.cpp font_simkai_20_4bpp_11.cpp font_simkai_20_4bpp_12.cpp font_simkai_20_4bpp_13.cpp font_simkai_20_4bpp_4.cpp font_simkai_26_4bpp_0.cpp font_simkai_26_4bpp_10.cpp font_simkai_26_4bpp_11.cpp font_simkai_26_4bpp_12.cpp font_simkai_26_4bpp_13.cpp font_simkai_26_4bpp_14.cpp font_simkai_26_4bpp_15.cpp font_simkai_26_4bpp_16.cpp font_simkai_26_4bpp_17.cpp font_simkai_26_4bpp_18.cpp font_simkai_26_4bpp_31.cpp font_simkai_26_4bpp_9.cpp font_verdana_13_4bpp_0.cpp font_verdana_20_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_cambriaz_40_4bpp.cpp kerning_simkai_16_4bpp.cpp kerning_simkai_20_4bpp.cpp kerning_simkai_26_4bpp.cpp kerning_verdana_13_4bpp.cpp kerning_verdana_20_4bpp.cpp table_cambriaz_40_4bpp.cpp table_simkai_16_4bpp.cpp table_simkai_20_4bpp.cpp table_simkai_26_4bpp.cpp table_verdana_13_4bpp.cpp table_verdana_20_4bpp.cpp unmappeddatafont.cpp
    ../touchgfx/generated/gui_generated/src/are_screen/: areviewbase.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp image_bg_1.cpp image_bg_10.cpp image_bg_11.cpp image_bg_14.cpp image_bg_15.cpp image_bg_16.cpp image_bg_17.cpp image_bg_18.cpp image_bg_2.cpp image_bg_3.cpp image_bg_31.cpp image_bg_32.cpp image_bg_4.cpp image_bg_5.cpp image_bg_6.cpp image_bg_7.cpp image_bg_8.cpp image_bg_9.cpp image_pg.cpp image_screenshot_2026-03-25_144431_073.cpp svgdatabase.cpp
    ../touchgfx/generated/gui_generated/src/coutton_screen/: couttonviewbase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/gui_generated/src/heat_screen/: heatviewbase.cpp
    ../touchgfx/generated/gui_generated/src/homescreen_screen/: homescreenviewbase.cpp
    ../touchgfx/generated/images/src/container/: image_alipay-60x60.cpp image_alipay_pressed-60x60.cpp image_backlight_off-50x50.cpp image_backlight_on-50x50.cpp image_beep_50x50.cpp image_beep_pressed_50x50.cpp image_breathe-60x60.cpp image_breathe_pressed-60x60.cpp image_chip.cpp image_count-60x60.cpp image_count_pressed-60x60.cpp image_dc_fan_50x50.cpp image_dc_fan__pressed_50x50.cpp image_heartrate_start_51x47.cpp image_humidity_22x28.cpp image_light_29x29.cpp image_lpbam_off-50x50.cpp image_lpbam_on-50x50.cpp image_message_50x50.cpp image_message_no-50x50.cpp image_mute_off-50x50.cpp image_mute_on-50x50.cpp image_overlay-240x240.cpp image_stm32u5_tb.cpp image_stress-60x60.cpp image_stress_pressed-60x60.cpp image_temperature_15x32.cpp image_tool.cpp image_vibrate_50x50.cpp image_vibrate_pressed_50x50.cpp image_water_off-50x50.cpp image_water_on-50x50.cpp image_wifi_rssi_1_signal.cpp image_wifi_rssi_2_signal.cpp image_wifi_rssi_3_signal.cpp image_wifi_rssi_4_signal.cpp image_wifi_rssi_no_signal.cpp image_wifilink-38x38.cpp image_wifilink-38x38_pressed.cpp image_wifilink_pressed-37x26.cpp
    ../touchgfx/generated/images/src/__generated/: image_alternate_theme_images_widgets_button_icon_round_micro_outline_action.cpp image_alternate_theme_images_widgets_button_icon_round_micro_outline_pressed.cpp image_alternate_theme_images_widgets_button_regular_height_36_tiny_rounded_inactive.cpp image_alternate_theme_images_widgets_button_regular_height_36_tiny_rounded_pressed.cpp image_alternate_theme_images_widgets_button_regular_height_50_medium_round_inactive.cpp image_alternate_theme_images_widgets_button_regular_height_50_tiny_round_inactive.cpp image_alternate_theme_images_widgets_togglebutton_small_round_small_off_dark.cpp image_alternate_theme_images_widgets_togglebutton_small_round_small_on_action.cpp image_icon_theme_images_navigation_arrow_back_ios_35_35_e8f6fb.svg.cpp image_icon_theme_images_navigation_arrow_forward_ios_35_35_e8f6fb.svg.cpp
    ../touchgfx/generated/images/src/apppage/: image_applicationpage_image_6050.cpp image_applicationpage_image_battery.cpp image_applicationpage_image_buzzer.cpp image_applicationpage_image_chipinfo.cpp image_applicationpage_image_health.cpp image_applicationpage_image_motor.cpp image_applicationpage_image_pressed_6050.cpp image_applicationpage_image_pressed_battery.cpp image_applicationpage_image_pressed_buzzer.cpp image_applicationpage_image_pressed_chip.cpp image_applicationpage_image_pressed_health.cpp image_applicationpage_image_pressed_motor.cpp image_applicationpage_image_pressed_temp.cpp image_applicationpage_image_pressed_wifi.cpp image_applicationpage_image_temp.cpp image_applicationpage_image_wifi.cpp
    ../touchgfx/generated/images/src/sportpage/: image_bigwhite1.cpp image_bigwhite2.cpp image_bigwhite3.cpp image_bigwhite4.cpp image_bigwhite5.cpp image_sport_cycling.cpp image_sport_indoor_running.cpp image_sport_outdoors_running.cpp image_sport_self_training.cpp image_sport_swimming.cpp image_sport_walk.cpp image_sportbegin.cpp image_sportstop.cpp image_sportsuspend.cpp
    ../touchgfx/generated/images/src/sixaxispage/: image_gauge_tiny_background.cpp image_gauge_tiny_needles_rough.cpp
    ../touchgfx/generated/images/src/hikingpage/: image_moveinfobkg.cpp
    ../touchgfx/generated/images/src/dialpage/: image_watchface_analog.cpp image_watchface_digital_circle.cpp image_watchhand_hour.cpp image_watchhand_minute.cpp image_watchhand_second.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/main_page_screen/: main_pageviewbase.cpp
    ../touchgfx/generated/gui_generated/src/oula_screen/: oulaviewbase.cpp
    ../touchgfx/generated/gui_generated/src/timer_screen/: timerviewbase.cpp
    ../touchgfx/generated/gui_generated/src/vcc_screen/: vccviewbase.cpp
    ../touchgfx/generated/gui_generated/src/wifi_screen/: wifiviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m33/Keil6.x/: touchgfx_core_wchar16.lib
  group motion
    ../Drivers/Motion_Driver/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group efsm-master
    ../Drivers/efsm-master/efsm/: efsm.c efsm_hal.c
  group MAX30102_Maxim
    ../Drivers/MAX30102_Maxim/: algorithm.c max30102.c
  group code
    ../code/: fun.c fun.h font.c
software components: CMSIS:CORE 4.3.0
